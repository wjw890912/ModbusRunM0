# Keil uVision project MyProject.uvproj, settings and files
target MyProject (ARM-ADS)
  device: M0516LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: MyProject
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\LibM051Series\CMSIS\CoreSupport;..\..\LibM051Series\CMSIS\DeviceSupport;..\..\LibM051Series\StdDriver\inc;..\..\LibM051Series\M051-LB_004_Driver\inc;..\..\Project;..\..\uCOS-II\Source;..\..\uCOS-II\Ports\ARM-Cortex-M0\Generic\RealView;..\..\uCOS-II\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../LibM051Series/CMSIS/CoreSupport/: core_cm0.c
    ../../LibM051Series/CMSIS/DeviceSupport/: system_M051Series.c startup_M051Series.s
  group Source files
    ../: Initialization.c main.c app_hooks.c ram.c uart_ad.c rambuf.c
  group Library files
    ../../LibM051Series/StdDriver/src/: retarget.c
  group uCOS src
    ../../uCOS-II/Source/: ucos_ii.c
  group uCOS port
    ../../uCOS-II/Ports/ARM-Cortex-M0/Generic/RealView/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group CFG
    ../: app_cfg.h os_cfg.h
